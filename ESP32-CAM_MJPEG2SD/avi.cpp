
/* 
生成录制视频的 AVI 格式
*/

/* AVI 文件格式：
文件头：
 310 字节
每个 jpeg：
 4 字节 00dc 标记
 4 字节 jpeg 大小
 jpeg 帧内容
 0-3 字节填充以对齐 DWORD 边界
每个 PCM（音频文件）：
 4 字节 01wb 标记
 4 字节 pcm 大小
 pcm 内容
 0-3 字节填充以对齐 DWORD 边界
文件尾：
 4 字节 idx1 标记
 4 字节索引大小
 每个 jpeg：
  4 字节 00dc 标记
  4 字节 0000
  4 字节 jpeg 位置
  4 字节 jpeg 大小
 每个 pcm：
  4 字节 01wb 标记
  4 字节 0000
  4 字节 pcm 位置
  4 字节 pcm 大小
*/

#include "appGlobals.h"

// avi 文件头数据
const uint8_t dcBuf[4] = {0x30, 0x30, 0x64, 0x63};   // 00dc
const uint8_t wbBuf[4] = {0x30, 0x31, 0x77, 0x62};   // 01wb
static const uint8_t idx1Buf[4] = {0x69, 0x64, 0x78, 0x31}; // idx1
static const uint8_t zeroBuf[4] = {0x00, 0x00, 0x00, 0x00}; // 0000
static uint8_t* idxBuf[2] = {NULL, NULL};

uint8_t aviHeader[AVI_HEADER_LEN] = { // AVI 文件头模板
  0x52, 0x49, 0x46, 0x46, 0x00, 0x00, 0x00, 0x00, 0x41, 0x56, 0x49, 0x20, 0x4C, 0x49, 0x53, 0x54,
  0x16, 0x01, 0x00, 0x00, 0x68, 0x64, 0x72, 0x6C, 0x61, 0x76, 0x69, 0x68, 0x38, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xe0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x4C, 0x49, 0x53, 0x54, 0x6C, 0x00, 0x00, 0x00,
  0x73, 0x74, 0x72, 0x6C, 0x73, 0x74, 0x72, 0x68, 0x30, 0x00, 0x00, 0x00, 0x76, 0x69, 0x64, 0x73,
  0x4D, 0x4A, 0x50, 0x47, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0A, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x73, 0x74, 0x72, 0x66,
  0x28, 0x00, 0x00, 0x00, 0x28, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0x00, 0x18, 0x00, 0x4D, 0x4A, 0x50, 0x47, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
  0x4C, 0x49, 0x53, 0x54, 0x56, 0x00, 0x00, 0x00, 
  0x73, 0x74, 0x72, 0x6C, 0x73, 0x74, 0x72, 0x68, 0x30, 0x00, 0x00, 0x00, 0x61, 0x75, 0x64, 0x73,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x11, 0x2B, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x11, 0x2B, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x73, 0x74, 0x72, 0x66,
  0x12, 0x00, 0x00, 0x00, 0x01, 0x00, 0x01, 0x00, 0x11, 0x2B, 0x00, 0x00, 0x11, 0x2B, 0x00, 0x00,
  0x02, 0x00, 0x10, 0x00, 0x00, 0x00, 
  0x4C, 0x49, 0x53, 0x54, 0x00, 0x00, 0x00, 0x00, 0x6D, 0x6F, 0x76, 0x69,
};

struct frameSizeStruct {
  uint8_t frameWidth[2];
  uint8_t frameHeight[2];
};
// 按帧类型索引 - 需与 sensor.h 中 framesize_t 枚举保持一致
static const frameSizeStruct frameSizeData[] = {
  {{0x60, 0x00}, {0x60, 0x00}}, // 96X96
  {{0xA0, 0x00}, {0x78, 0x00}}, // qqvga 
  {{0x80, 0x00}, {0x80, 0x00}}, // 128X128
  {{0xB0, 0x00}, {0x90, 0x00}}, // qcif 
  {{0xF0, 0x00}, {0xB0, 0x00}}, // hqvga 
  {{0xF0, 0x00}, {0xF0, 0x00}}, // 240X240
  {{0x40, 0x01}, {0xF0, 0x00}}, // qvga 
  {{0x40, 0x01}, {0x40, 0x01}}, // 320X320
  {{0x90, 0x01}, {0x28, 0x01}}, // cif 
  {{0xE0, 0x01}, {0x40, 0x01}}, // hvga 
  {{0x80, 0x02}, {0xE0, 0x01}}, // vga 
  {{0x20, 0x03}, {0x58, 0x02}}, // svga 
  {{0x00, 0x04}, {0x00, 0x03}}, // xga 
  {{0x00, 0x05}, {0xD0, 0x02}}, // hd
  {{0x00, 0x05}, {0x00, 0x04}}, // sxga
  {{0x40, 0x06}, {0xB0, 0x04}}, // uxga 
  {{0x98, 0x03}, {0x38, 0x04}}, // FHD
  {{0xD0, 0x02}, {0x00, 0x05}}, // P_HD
  {{0x60, 0x03}, {0x00, 0x06}}, // P_3MP
  {{0x00, 0x08}, {0x00, 0x06}}, // QXGA
  {{0x00, 0x0A}, {0xA0, 0x05}}, // QHD
  {{0x00, 0x0A}, {0x40, 0x06}}, // WQXGA
  {{0x38, 0x04}, {0x80, 0x07}}, // P_FHD
  {{0x00, 0x0A}, {0x80, 0x07}}, // QSXGA
  {{0x20, 0x0A}, {0x98, 0x07}}  // 5MP
};

#define IDX_ENTRY 16 // 每条索引项的字节数

// 运动捕获和延时摄影使用独立索引
static size_t idxPtr[2];
static size_t idxOffset[2];
static size_t moviSize[2];
static size_t audSize;
static size_t indexLen[2];
static File wavFile;
bool haveSoundFile = false;

void prepAviIndex(bool isTL) {
  // 准备缓冲区存储索引数据，追加到文件末尾
  if (idxBuf[isTL] == NULL) idxBuf[isTL] = (uint8_t*)ps_malloc((maxFrames+2)*IDX_ENTRY); // 包含文件头和音频索引的空间
  memcpy(idxBuf[isTL], idx1Buf, 4); // 索引文件头
  idxPtr[isTL] = CHUNK_HDR;  // 为索引大小预留 4 字节
  moviSize[isTL] = indexLen[isTL] = 0;
  idxOffset[isTL] = 4; // 4 字节偏移
}

void buildAviHdr(uint8_t FPS, uint8_t frameType, uint16_t frameCnt, bool isTL) {
  // 用文件特定信息更新 AVI 文件头模板
  size_t aviSize = moviSize[isTL] + AVI_HEADER_LEN + ((CHUNK_HDR+IDX_ENTRY) * (frameCnt+(haveSoundFile?1:0))); // AVI 内容大小 
  // 用相关统计数据更新 aviHeader
  memcpy(aviHeader+4, &aviSize, 4);
  uint32_t usecs = (uint32_t)round(1000000.0f / FPS); // 每帧微秒数 
  memcpy(aviHeader+0x20, &usecs, 4); 
  memcpy(aviHeader+0x30, &frameCnt, 2);
  memcpy(aviHeader+0x8C, &frameCnt, 2);
  memcpy(aviHeader+0x84, &FPS, 1);
  uint32_t dataSize = moviSize[isTL] + ((frameCnt+(haveSoundFile?1:0)) * CHUNK_HDR) + 4; 
  memcpy(aviHeader+0x12E, &dataSize, 4); // 数据大小 

  // 将视频帧尺寸写入 avi 文件头
  memcpy(aviHeader+0x40, frameSizeData[frameType].frameWidth, 2);
  memcpy(aviHeader+0xA8, frameSizeData[frameType].frameWidth, 2);
  memcpy(aviHeader+0x44, frameSizeData[frameType].frameHeight, 2);
  memcpy(aviHeader+0xAC, frameSizeData[frameType].frameHeight, 2);

#if INCLUDE_AUDIO
  uint8_t withAudio = 2; // 为音频增加流数量
  if (isTL) memcpy(aviHeader+0x100, zeroBuf, 4); // 延时摄影无音频
  else {
    if (haveSoundFile) memcpy(aviHeader+0x38, &withAudio, 1); 
    memcpy(aviHeader+0x100, &audSize, 4); // 音频数据大小
  }
  // 将音频详情写入 avi 文件头
  memcpy(aviHeader+0xF8, &SAMPLE_RATE, 4);
  uint32_t bytesPerSec = SAMPLE_RATE * 2;
  memcpy(aviHeader+0x104, &bytesPerSec, 4); // 建议缓冲区大小
  memcpy(aviHeader+0x11C, &SAMPLE_RATE, 4);
  memcpy(aviHeader+0x120, &bytesPerSec, 4); // 每秒字节数
#else
  memcpy(aviHeader+0x100, zeroBuf, 4);
#endif

  // 重置状态以备下次录制
  moviSize[isTL] = idxPtr[isTL] = 0;
  idxOffset[isTL] = 4; // 4 字节偏移
}

void buildAviIdx(size_t dataSize, bool isVid, bool isTL) {
  // 将 AVI 视频索引构建到缓冲区 - 每帧 16 字节
  // 由 saveFrame() 对每帧调用
  moviSize[isTL] += dataSize;
  if (idxPtr[isTL] + IDX_ENTRY > (maxFrames+2)*IDX_ENTRY) doRestart("Need to reboot if max frames changed");
  if (isVid) memcpy(idxBuf[isTL]+idxPtr[isTL], dcBuf, 4);
  else memcpy(idxBuf[isTL]+idxPtr[isTL], wbBuf, 4);
  memcpy(idxBuf[isTL]+idxPtr[isTL]+4, zeroBuf, 4);
  memcpy(idxBuf[isTL]+idxPtr[isTL]+8, &idxOffset[isTL], 4); 
  memcpy(idxBuf[isTL]+idxPtr[isTL]+12, &dataSize, 4); 
  idxOffset[isTL] += dataSize + CHUNK_HDR;
  idxPtr[isTL] += IDX_ENTRY; 
}

size_t writeAviIndex(byte* clientBuf, size_t buffSize, bool isTL) {
  // 将完成的索引写入 avi 文件
  // 由 closeAvi() 重复调用直到返回 0
  if (idxPtr[isTL] < indexLen[isTL]) {
    if (indexLen[isTL]-idxPtr[isTL] > buffSize) {
      memcpy(clientBuf, idxBuf[isTL]+idxPtr[isTL], buffSize);
      idxPtr[isTL] += buffSize;
      return buffSize;
    } else {
      // 索引的最后部分
      size_t final = indexLen[isTL]-idxPtr[isTL];
      memcpy(clientBuf, idxBuf[isTL]+idxPtr[isTL], final);
      idxPtr[isTL] = indexLen[isTL];
      return final;    
    }
  }
  return idxPtr[isTL] = 0;
}
  
void finalizeAviIndex(uint16_t frameCnt, bool isTL) {
  // 用大小更新索引
  uint32_t sizeOfIndex = (frameCnt+(haveSoundFile?1:0))*IDX_ENTRY;
  memcpy(idxBuf[isTL]+4, &sizeOfIndex, 4); // 索引大小 
  indexLen[isTL] = sizeOfIndex + CHUNK_HDR;
  idxPtr[isTL] = 0; // 索引缓冲区指针
}

bool haveWavFile(bool isTL) {
  haveSoundFile = false;
  audSize = 0;
#if INCLUDE_AUDIO
  if (isTL) return false;
  // 检查 wav 文件是否存在
  if (!STORAGE.exists(WAVTEMP)) return 0; 
  // 打开并获取大小
  wavFile = STORAGE.open(WAVTEMP, FILE_READ);
  if (wavFile) {
    // 添加音频文件索引
    audSize = wavFile.size() - WAV_HDR_LEN;
    buildAviIdx(audSize, false); 
    // 添加音频文件头    
    wavFile.seek(WAV_HDR_LEN, SeekSet); // 跳过文件头
    haveSoundFile = true;
  } 
#endif
  return haveSoundFile;
}

size_t writeWavFile(byte* clientBuf, size_t buffSize) {
  // 读取 wav 文件并写入 avi 文件
  // 由 closeAvi() 重复调用直到返回 0
  static size_t offsetWav = CHUNK_HDR;
  if (offsetWav) {
    // 添加音频文件头         
    memcpy(clientBuf, wbBuf, 4);     
    memcpy(clientBuf+4, &audSize, 4); 
  } 
  size_t readLen = wavFile.read(clientBuf+offsetWav, buffSize-offsetWav) + offsetWav; 
  offsetWav = 0;
  if (readLen) return readLen; 
  // 完成时到达此处
  wavFile.close();
  STORAGE.remove(WAVTEMP);
  offsetWav = CHUNK_HDR;
  return 0;
}
